# Keil uVision project STM32F407ZGT6.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407ZGT6 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\STM32F4xx_StdPeriph_Driver\inc;..\User;..\MDK-ARM;..\Hardware\inc;..\System;..\ESP8266;..\uCOSIII\uC-CPU;..\uCOSIII\uC-LIB;..\uCOSIII\uCOS-III;..\uCOSIII\uCOS-BSP;..\uCOSIII\uCOS-CONFIG;..\uCOSIII\uCOS-III\Source;..\uCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\uCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\uCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group System
    ../System/: delay.c sys.c usart.c
  group Hardware
    ../Hardware/src/: led.c key.c exti.c pwm.c usart3.c timer.c malloc.c ReedSwitch.c oled.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ESP8266
    ../ESP8266/: wifi.c motor.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group uCOSIII-BSP
    ../uCOSIII/uCOS-BSP/: bsp.c
  group uCOSIII-CPU
    ../uCOSIII/uC-CPU/: cpu_core.c
    ../uCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group uCOSIII-LIB
    ../uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOSIII-CORE
    ../uCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOSIII-PORT
    ../uCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOSIII-CONFIG
    ../uCOSIII/uCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Readme
    ../Doc/: stm32库移植.txt IO口模式选择.txt 1.按键LED灯例程.txt 2.串口发送接收例程.txt 定时器区别.txt
